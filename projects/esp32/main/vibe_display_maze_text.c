#include "vibe_display_maze_text.h"

#include <ctype.h>
#include <string.h>

#include "vibe_display_draw.h"

static uint8_t maze_glyph_row(char c, int row);

int vibe_display_maze_text_width(const char *text, int scale)
{
    if (text == NULL) {
        return 0;
    }

    return (int)strlen(text) * 4 * scale;
}

void vibe_display_maze_text_draw(int x, int y, const char *text, int scale, uint16_t color, int max_x)
{
    if (text == NULL) {
        return;
    }

    int cursor = x;
    for (const char *p = text; *p != '\0' && cursor < max_x - 4; p++) {
        char c = (char)toupper((unsigned char)*p);
        if (c == ' ') {
            cursor += 4 * scale;
            continue;
        }

        for (int row = 0; row < 5; row++) {
            uint8_t bits = maze_glyph_row(c, row);
            for (int col = 0; col < 3; col++) {
                if (bits & (1 << (2 - col))) {
                    vibe_display_draw_fill_rect(cursor + col * scale, y + row * scale, scale, scale, color);
                }
            }
        }
        cursor += 4 * scale;
    }
}

void vibe_display_maze_text_draw_centered(int left, int right, int y, const char *text, uint16_t color, int max_x)
{
    const int scale = 2;
    int width = vibe_display_maze_text_width(text, scale);
    int x = left + ((right - left + 1) - width) / 2;
    if (x < left) {
        x = left;
    }
    vibe_display_maze_text_draw(x, y, text, scale, color, max_x);
}

static uint8_t maze_glyph_row(char c, int row)
{
    static const uint8_t digits[10][5] = {
        {0x07, 0x05, 0x05, 0x05, 0x07},
        {0x02, 0x06, 0x02, 0x02, 0x07},
        {0x07, 0x01, 0x07, 0x04, 0x07},
        {0x07, 0x01, 0x07, 0x01, 0x07},
        {0x05, 0x05, 0x07, 0x01, 0x01},
        {0x07, 0x04, 0x07, 0x01, 0x07},
        {0x07, 0x04, 0x07, 0x05, 0x07},
        {0x07, 0x01, 0x01, 0x01, 0x01},
        {0x07, 0x05, 0x07, 0x05, 0x07},
        {0x07, 0x05, 0x07, 0x01, 0x07},
    };
    static const uint8_t letters[26][5] = {
        {0x02, 0x05, 0x07, 0x05, 0x05},
        {0x06, 0x05, 0x06, 0x05, 0x06},
        {0x07, 0x04, 0x04, 0x04, 0x07},
        {0x06, 0x05, 0x05, 0x05, 0x06},
        {0x07, 0x04, 0x06, 0x04, 0x07},
        {0x07, 0x04, 0x06, 0x04, 0x04},
        {0x07, 0x04, 0x05, 0x05, 0x07},
        {0x05, 0x05, 0x07, 0x05, 0x05},
        {0x07, 0x02, 0x02, 0x02, 0x07},
        {0x01, 0x01, 0x01, 0x05, 0x07},
        {0x05, 0x05, 0x06, 0x05, 0x05},
        {0x04, 0x04, 0x04, 0x04, 0x07},
        {0x05, 0x07, 0x07, 0x05, 0x05},
        {0x05, 0x07, 0x07, 0x07, 0x05},
        {0x07, 0x05, 0x05, 0x05, 0x07},
        {0x07, 0x05, 0x07, 0x04, 0x04},
        {0x07, 0x05, 0x05, 0x07, 0x01},
        {0x06, 0x05, 0x06, 0x05, 0x05},
        {0x07, 0x04, 0x07, 0x01, 0x07},
        {0x07, 0x02, 0x02, 0x02, 0x02},
        {0x05, 0x05, 0x05, 0x05, 0x07},
        {0x05, 0x05, 0x05, 0x05, 0x02},
        {0x05, 0x05, 0x07, 0x07, 0x05},
        {0x05, 0x05, 0x02, 0x05, 0x05},
        {0x05, 0x05, 0x02, 0x02, 0x02},
        {0x07, 0x01, 0x02, 0x04, 0x07},
    };

    if (row < 0 || row >= 5) {
        return 0;
    }
    if (c >= '0' && c <= '9') {
        return digits[c - '0'][row];
    }
    if (c >= 'A' && c <= 'Z') {
        return letters[c - 'A'][row];
    }
    return 0;
}
